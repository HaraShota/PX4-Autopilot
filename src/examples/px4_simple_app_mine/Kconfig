## src/examples/px4_simple_app_mine/Kconfig
```kconfig
menuconfig EXAMPLES_PX4_SIMPLE_APP_MINE
	bool "px4_simple_app_mine"
	default n
	---help---
		Enable support for px4_simple_app_mine
```
